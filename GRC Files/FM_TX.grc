options:
  parameters:
    author: Lantzos Stergios
    generate_options: qt_gui
    id: FM_TX
    output_language: python
    title: FM Transmitter
  states: {}

blocks:
- name: Low_Pass_gain
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: Transmit_Station
  id: variable
  parameters:
    value: '107600000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '50'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    comment: |-
      Improves the signal-to-noise ratio 
      of the audio transmission
    fh: '-1'
    samp_rate: audio_rate
    tau: '50e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: interpolation*1000
    comment: |-
      Frequency Modulation.
      Using deviation 75.000Hz, which
      is the maximum Deviation of 
      a Frequency Modulated signal.
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: audio_source_2_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '500000'
    buffer_size: '60000'
    comment: |-
      PlutoSDR transmits our FM Signal.

      Maximum output occurs
      at 0 attenuation.
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: Transmit_Station
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      MIN FM BANDWIDTH: 200kHz
      The more we increase the gain of 
      the Low Pass Filter, the stronger the 
      signal becomes.
      HINT: if you have Adalm-Pluto default 
      antennas, you need to have closer 
      your RadioReceiver(e.g Phone defaults Radio)
    cutoff_freq: '100000'
    decim: '1'
    gain: Low_Pass_gain
    samp_rate: quad_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Microphone's In
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '384000'
    fc: Transmit_Station
    fftsize: '4096'
    name: Signal's Transmission
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 'OUT: 50kS/s'
    decim: int (audio_rate / 1000)
    interp: interpolation
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 'OUT: 384kS/s'
    decim: int(quad_rate / 1000)
    interp: int (samp_rate / 1000)
    type: ccc
  states: {}

connections:
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [audio_source_2_0, '0', analog_fm_preemph_0, '0']
- [audio_source_2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0_0, '0', iio_pluto_sink_0_0, '0']

metadata:
  file_format: 1
