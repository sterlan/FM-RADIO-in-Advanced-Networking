options:
  parameters:
    author: Lantzos Stergios
    generate_options: qt_gui
    id: FM_RX
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: Tuning
  id: variable_qtgui_chooser
  parameters:
    label: FM STATIONS
    label0: Radio Star FM 95.3 (-stereo-)
    label1: TRANSMIT FM 107.6
    label2: Radio Laikos Volos 103 FM
    label3: Power FM VOLOS
    label4: PERFECT RADIO 103.3
    num_opts: '5'
    option0: '95300000'
    option1: '107600000'
    option2: '103000000'
    option3: '100200000'
    option4: '103300000'
    type: raw
    value: '95300000'
    widget: radio_buttons
  states: {}
- name: downsample
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: fsk_max_deviation_hz
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    comment: Reduces the high frequency content of the received signal
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: 'MIN FM bandwidth: 200 kHz'
    quad_rate: downsample
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '10'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '19100'
    low_cutoff_freq: '18900'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '59400'
    low_cutoff_freq: '54600'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/stergios/Desktop/output.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '500000'
    bbdc: 'True'
    buffer_size: '60000'
    filter_source: '''Auto'''
    frequency: Tuning
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '75000'
    decim: '1'
    gain: '1'
    samp_rate: downsample
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'MONO AUDIO '
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: STEREO
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: RDS
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: 'FM  '
  states: {}
- name: note_1
  id: note
  parameters:
    note: PILOT TONE
  states: {}
- name: note_3
  id: note
  parameters:
    note: PLOTS
  states: {}
- name: note_4
  id: note
  parameters:
    note: FM RECEIVE
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: (FM MONO AUDIO)
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: (FM PILOT TONE)
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: (FM STEREO AUDIO)
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: (FM RDS)
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: (FM SIGNAL)
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: FM SIGNAL WATERFALL
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 'OUT: 48.000 S/s'
    decim: '4166'
    interp: '1000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 'OUT: 200.000 S/s'
    decim: '192'
    interp: '100'
    type: ccc
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_fm_deemph_0, '0', blocks_wavfile_sink_0, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0_1, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0_1_1, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0_1_1_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [band_pass_filter_0_1, '0', qtgui_freq_sink_x_1_0_0_0, '0']
- [band_pass_filter_0_1_1, '0', qtgui_freq_sink_x_1_0_0_0_0, '0']
- [band_pass_filter_0_1_1_0, '0', qtgui_freq_sink_x_1_0_0_0_0_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0_1_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
