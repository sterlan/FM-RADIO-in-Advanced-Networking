options:
  parameters:
    author: Lantzos Stergios
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: RRC_GAIN
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '37'
  states: {}
- name: Tuning
  id: variable_qtgui_chooser
  parameters:
    label: FM STATIONS
    label0: Radio Star FM 95.3 (-stereo-)
    label1: TRANSMIT FM 107.6
    label2: Radio Laikos Volos 103 FM
    label3: Power FM VOLOS
    label4: PERFECT RADIO 103.3
    num_opts: '5'
    option0: '95300000'
    option1: '107600000'
    option2: '103000000'
    option3: '100200000'
    option4: '103300000'
    type: raw
    value: '95300000'
    widget: radio_buttons
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: downsample
  id: variable
  parameters:
    value: '19000'
  states: {}
- name: fm_fsk_deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: pluto_samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1'
    comment: |-
      The more taps we use, the more accurate the
      Matched Filter becomes.
      The FM-RDS Transmitters, use Root Raise Cosine Filter
      for Spectral Efficiency(more data in the same bandwidth)
      and for the reduction of ISI. Now, we need also to design a proper
      Matched Filter , that shapes these symbols.
    gain: RRC_GAIN
    ntaps: 11*48
    samp_rate: downsample
    sym_rate: symbol_rate
  states: {}
- name: rrc_taps_for_manchester
  id: variable
  parameters:
    comment: |-
      Bi-phase Coding: 
      -logic 0 -> [-1,1] 
      or a e(t) = d(t) - d(t - td/2) = -1 -1 = -2 < 0 -> logic 0

      -logic 1 -> [1,-1]
      or e(t) = d(t) - d(t - td/2) = 1 - (-1) = + 2 > 0 -> logic 1

      where td = one data clock period, 
      at 1/1187.5 s.

      So, working on samples(in a 
      Sample Rate of 19.000S/s) and 
      a total bit rate of 2375 bits/s, we 
      know that every 8 samples, a new impulse occurs.
      So, the difference between the two halves of a 
      Manchester Symbol, are 8 samples apart.
      So, in samples:
      Bi-PhaseSymbol = value[now] - value[now + 8]. 
      This formula represents a bi-Phase symbol, 
      according to the
      equations, causing a Baud reduction to half
      Tha result is the convolution of 
      the RRC filter with one Manchester-encoded bit.
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: rx_gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '228000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '2375'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    comment: |-
      Clears more the sound 
      from the backround's hisses,
      if they exist.
    samp_rate: audio_rate
    tau: '50e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Demodulating the 
      FM Signal.
    gain: samp_rate / (2*math.pi*fm_fsk_deviation)
  states: {}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: 'FM bandwidth: 200 kHz'
    quad_rate: '228000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Extract the RDS-Bandwidth.
    decim: '1'
    gain: '1'
    high_cutoff_freq: '59400'
    low_cutoff_freq: '54600'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      RDS Centered at 0.
      (Shifting the RDS to our
      Baseband).
    freq: '-57000'
    sample_rate: samp_rate
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: BPSK DEMODULATION
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Costas is used to lock onto the carrier frequency 
      of the FM signal and recover the modulating data. 
      Generates a local oscillator signal that is in phase 
      and frequency-locked to the incoming carrier, 
      which allows for accurate recovery of the RDS data.
      Order 2 if the signal is 
      BPSK modulated.
    order: '2'
    w: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Differential Decoding
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Timing Recover or Time Sync.
      The bit rate is 1187.5 bit/s
      and the samp_rate remains at 19kS/s, 
      so the exact number of Samples per 
      Symbols now is 16. This block, calculates
      and selects the best samples for each 
      symbol.
    damping: '1.0'
    loop_bw: math.pi /100
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: |-
      This filter isolates the digital signal in a bandwidth of a 
      few kHz and reject all the other spectral components. 
      Also, works as a Matched Filter for 
      Bi-Phase Symbols, causing Baud reduction.
    decim: '1'
    samp_rate: '19000'
    taps: rrc_taps_for_manchester
    type: ccc
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '500000'
    bbdc: 'True'
    buffer_size: '60000'
    filter_source: '''Auto'''
    frequency: Tuning
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: pluto_samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2400'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: note_1
  id: note
  parameters:
    note: The baseband signal is differentially encoded and Manchester encoded, resulting in a symbol rate of 2375 baud.
  states: {}
- name: note_13
  id: note
  parameters:
    note: SIGNAL DEMODULATION
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '512'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '1'
    size: '512'
    srate: '19000'
    type: complex
    yunit: COSTAS LOOP CARRIER RECOVERY SYNC
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: FM SIGNAL RECEIVED BY ADALM-PLUTO
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    freqhalf: 'False'
    name: RDS SIGNAL CENTERED AT 0
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '19000'
    fc: '0'
    fftsize: '2048'
    name: MATCHED FILTER
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 'OUT: 228.000S/s'
    decim: pluto_samp_rate
    interp: samp_rate
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    comment: Downsampling to 48Ks/s
    decim: samp_rate
    interp: audio_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    comment: |-
      OUT: 19.000 Samples/Second. 
      Since we are working with Samples, 
      we need to have an exact number
      of Samples/Symbols. 
      The officialy bit/rate of RDS is 
      1187.5 Bits/s (= 57.000kHz / 48 Cycles), 
      but using Bi-Phase(or Manchester) Encoding
      (which double checks 
      each Symbol), the bit rate is doubled, 
      at 2375 bits/Sec.
    decim: samp_rate
    interp: downsample
    type: ccc
  states: {}
- name: rds_decoder_0_0
  id: rds_decoder
  parameters:
    comment: RDS digital data decoding(grouped in Bytes)
  states: {}
- name: rds_panel_0_0
  id: rds_panel
  parameters:
    freq: Tuning
  states: {}
- name: rds_parser_0_0
  id: rds_parser
  parameters:
    comment: Parsing RDS-Bytes.
    log: 'True'
    pty_locale: '0'
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_1, '0', qtgui_freq_sink_x_2, '0']
- [analog_wfm_rcv_1, '0', rational_resampler_xxx_0_1, '0']
- [band_pass_filter_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_diff_decoder_bb_0_0, '0', rds_decoder_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', digital_symbol_sync_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', qtgui_sink_x_0_0, '0']
- [iio_pluto_source_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_3, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_wfm_rcv_1, '0']
- [rational_resampler_xxx_0_1, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_2, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [rds_decoder_0_0, out, rds_parser_0_0, in]
- [rds_parser_0_0, out, rds_panel_0_0, in]

metadata:
  file_format: 1
