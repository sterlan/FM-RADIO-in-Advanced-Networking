options:
  parameters:
    author: Lantzos Stergios
    generate_options: qt_gui
    id: FM_broadcast_stereo_receiver
    output_language: python
    title: FM_broadcast_stereo_receiver
  states: {}

blocks:
- name: Tuning
  id: variable_qtgui_chooser
  parameters:
    label: FM STATIONS
    label0: Radio Star FM 95.3 (-stereo-)
    label1: TRANSMIT FM 107.6
    label2: Radio Laikos Volos 103 FM
    label3: Power FM VOLOS
    label4: PERFECT RADIO 103.3
    num_opts: '5'
    option0: '95300000'
    option1: '107600000'
    option2: '103000000'
    option3: '100200000'
    option4: '103300000'
    type: raw
    value: '95300000'
    widget: radio_buttons
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    comment: |-
      Reducing the high frequency 
      content of the received signal.
      (Making the Sound more clear)
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_pll_refout_cc_1
  id: analog_pll_refout_cc
  parameters:
    comment: |-
      PLL which locks to the input frequency and outputs a carrier. 
      Result: a clean 19kHz carrier that is phase-locked to the input one
    max_freq: 2 * math.pi * (19000+4) / 200000
    min_freq: 2 * math.pi * (19000-4) / 200000
    w: 2 * math.pi /100
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: |-
      Alloable MIN Bandwidth: 200kHz
      FM Signal Reception and Demodulation.
    quad_rate: '200000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1_0_0
  id: band_pass_filter
  parameters:
    comment: Extract the Pilot Tone.
    decim: '1'
    gain: '1'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '200000'
    type: fir_filter_fcc
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '38200'
    low_cutoff_freq: '37800'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    comment: L + R + (L - R) = 2L
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: |-
      OUT: 38kHz Carrier , 
      which is locked in 
      Phase with 
      the Pilot tone.
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    comment: L-R SIDEBANDS CENTERED AT 0
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: L + R - (L - R) = 2R
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '500000'
    bbdc: 'True'
    buffer_size: '60000'
    filter_source: '''Auto'''
    frequency: Tuning
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: quad_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Mono Audio(30-15000 Hz)
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Stero (23-53 kHz)
  states: {}
- name: note_2
  id: note
  parameters:
    note: Pilot Tone(19kHz)
  states: {}
- name: note_5
  id: note
  parameters:
    note: L-R at 0-15kHz
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: FM SIGNAL RECEIVED BY PLUTO
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: MONO(L+R)
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: '23-53 kHz Stereo '
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: L-R at 0-15kHz
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '200000'
    fc: '0'
    fftsize: '4096'
    name: 38kHZ SUBCARRIER REGENERATED
    type: float
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: 'OUT: 200.000 S/s'
    decim: '192'
    interp: '100'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    comment: 'OUT: 48.000S/s'
    decim: '200000'
    interp: '48000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '48000'
    type: fff
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_1, '0']
- [analog_fm_deemph_0_0, '0', audio_sink_1, '1']
- [analog_pll_refout_cc_1, '0', blocks_multiply_xx_1, '0']
- [analog_pll_refout_cc_1, '0', blocks_multiply_xx_1, '1']
- [analog_wfm_rcv_0, '0', band_pass_filter_1_0, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_1_0_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_2_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [band_pass_filter_1_0, '0', blocks_multiply_xx_1_0, '0']
- [band_pass_filter_1_0, '0', qtgui_freq_sink_x_0_0_0_0_0_0_0, '0']
- [band_pass_filter_1_0_0, '0', analog_pll_refout_cc_1, '0']
- [band_pass_filter_2, '0', blocks_multiply_xx_1_0, '1']
- [band_pass_filter_2, '0', qtgui_freq_sink_x_0_0_0_0_0_0_2, '0']
- [blocks_add_xx_2, '0', rational_resampler_xxx_0_1, '0']
- [blocks_complex_to_real_0, '0', band_pass_filter_2, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_2, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_0_1_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_2, '0', blocks_add_xx_2, '0']
- [low_pass_filter_2, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_2, '0', qtgui_freq_sink_x_0_0_0_0_0_0_1, '0']
- [low_pass_filter_2_0, '0', blocks_add_xx_2, '1']
- [low_pass_filter_2_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_2_0, '0', qtgui_freq_sink_x_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_1, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_0_1_0, '0', analog_fm_deemph_0_0, '0']

metadata:
  file_format: 1
