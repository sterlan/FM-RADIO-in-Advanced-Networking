options:
  parameters:
    author: Lantzos Stergios
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: FM Tranmitter
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '2375'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '48'
  states: {}
- name: downsample
  id: variable
  parameters:
    value: '19000'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '384'
  states: {}
- name: low_pass_cutoff_freq
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: max_fm_deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: mono_gain
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: pilot_gain
  id: variable
  parameters:
    value: '0.09'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: stereo_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_preemph_0_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_rate
    tau: '50e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi * max_fm_deviation / samp_rate
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.09'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '0.03'
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: stereo_gain
    high_cutoff_freq: 53e3
    low_cutoff_freq: 23e3
    samp_rate: audio_rate*interpolation/decimation
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '10'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    comment: |-
      L+R
      (MONO AUDIO)
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: RDS centered in 57kHz
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      L-R Sidebands
      centered at 38kHz.
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      The baseband signal is differentially 
      encoded and also Bi-Phase, resulting 
      in a symbol rate of 2375 bits/sec.
      (RDS Standards).
      In common words, we need:
      Samp_rate/interpolation = 2375
    interp: int(samp_rate/ baud)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: |-
      L-R
      (STEREO AUDIO)
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      K = 2(number of bytes 
      that represent
      a signal value of 
      "1" or "2"). 
      So:
      -input "1" -> 01
      -input "2" -> 10
      NEXT STEP: 
      -01 -> [00000000], [00000001]
      -10 -> [00000001], [00000000]
    k: '2'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/stergios/Desktop/Advanced_Networks/Final_Files/PROJECT_LANTZOS_STERGIOS/Digital Presentation_48000.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      Modulus 2 with differential encoding:
      -> "1" is represented by a change 
      in the signal phase  
      -> "0" is  represented by no change,

      Diff Encoding with modulus 2,
      is the same as X-OR operation between
      the New Input and the previous one. So, If 
      the new input is "0", the output remains 
      as it was, and if the new input is "1",
      the output is the complement of the previous
      input.
    modulus: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      "0" -> map[0] = 1 
      "1" -> map[1] = 2 -
    map: '[1,2]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      input 0 -> map[0] = -1
      input 1 -> map[1] = 1
    map: '[-1,1]'
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '500000'
    buffer_size: '60000'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '107600000'
    samplerate: '384000'
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff_freq
    gain: '1'
    interp: '1'
    samp_rate: audio_rate*interpolation/decimation
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_cutoff_freq
    gain: '1'
    interp: '1'
    samp_rate: audio_rate*interpolation/decimation
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: mono_gain
    samp_rate: audio_rate*interpolation/decimation
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '2400'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_15
  id: note
  parameters:
    note: PILOT CARRIER
  states: {}
- name: note_16
  id: note
  parameters:
    note: STEREO CARRIER
  states: {}
- name: note_4_1
  id: note
  parameters:
    comment: '"Building" the MONO-Audio(L+R) and the STEREO-Audio(L-R)'
    note: STAGE 1
  states: {}
- name: note_4_1_0
  id: note
  parameters:
    comment: Raw Data RDS. Differentialy Encoded, Bi-Phase Encoded in a bit Rate of 2375 baud
    note: STAGE 2
  states: {}
- name: note_4_1_1
  id: note
  parameters:
    comment: FREQUENCY MODULATION AND TRANSMITION via Adalm-Pluto
    note: STAGE 3
  states: {}
- name: note_5
  id: note
  parameters:
    note: Bi-Phase Encoding(= Manchester)
  states: {}
- name: note_7_0
  id: note
  parameters:
    note: CARRIERS
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: Signal before Frequency Modulation
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Differential Manchester Encoding
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Symbol Rate = 2375
    size: '512'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Pulse Shaping for reduction of ISI(RRC)
    size: '512'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: interpolation
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: interpolation
    taps: ''
    type: fff
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 107.6e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: 'HY448 FM '
    pty: '13'
    pty_locale: '0'
    radiotext: FM-RDS Transmitter via Gnu Radio 3.10.1.1! Enjoy :)
    ta: 'False'
    tp: 'True'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    comment: |-
      Root Raised Cosine Filter
      for reduction of ISI and 
      Spectral Efficiency.
    decim: '1'
    gain: '1'
    ntaps: '151'
    samp_rate: samp_rate
    sym_rate: '2375'
    type: fir_filter_fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: MONO_to_add
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: STEREO_to_add
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: PILOT CARRIER
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: STEREO CARRIER
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: RDS CARRIER
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: RDS_to_add
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RDS CARRIER
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: STEREO CARRIER
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: STEREO_to_add
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: PILOT CARRIER
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: MONO_to_add
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: RDS_to_add
  states: {}

connections:
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_fm_preemph_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', iio_pluto_sink_0_0, '0']
- [analog_sig_source_x_1, '0', band_pass_filter_1, '0']
- [analog_sig_source_x_1, '0', virtual_sink_1, '0']
- [analog_sig_source_x_2, '0', virtual_sink_2, '0']
- [band_pass_filter_0, '0', virtual_sink_0_0, '0']
- [band_pass_filter_1, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_1, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_1, '0', blocks_multiply_xx_1, '2']
- [blocks_add_xx_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0_0, '0', low_pass_filter_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_repeat_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_4, '0']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', virtual_sink_3, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_repeat_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_0_0, '0']
- [blocks_wavfile_source_0, '0', analog_fm_preemph_0_0, '0']
- [blocks_wavfile_source_0, '1', analog_fm_preemph_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0_0, '0']
- [low_pass_filter_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0_0, '1']
- [low_pass_filter_0_0, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_1, '0', virtual_sink_0, '0']
- [low_pass_filter_2, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rds_encoder_0, '0', digital_diff_encoder_bb_0, '0']
- [root_raised_cosine_filter_0, '0', low_pass_filter_2, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_1, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0, '2']
- [virtual_source_3, '0', blocks_add_xx_0, '1']
- [virtual_source_4, '0', blocks_add_xx_0, '3']
- [virtual_source_5, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
